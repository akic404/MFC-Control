# Keil uVision project DAC8563.uvprojx, settings and files
target DAC8563 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DAC8563 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\User;..\CMSIS;..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\User\Delay;..\User\CharLCD;..\User\PeripheralInit;..\User\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c PeripheralInit.c Delay.c key.c lze_lcd.c spi.c dac8563.c AD.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/STM32F10x/: system_stm32f10x.c
  group Startup
    ../CMSIS/DeviceSupport/STM32F10x/: startup_stm32f10x_hd.s
